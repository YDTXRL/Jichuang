# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay.h Delay.c fb.c Key.c Key.h main.c MatrixKey.c MatrixKey.h Timer0.c Timer0.h Nixie.c Nixie.h Input.c
